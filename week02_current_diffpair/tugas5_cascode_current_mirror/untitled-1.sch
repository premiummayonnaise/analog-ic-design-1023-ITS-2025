** sch_path: week02_current_diffpair/tugas5_cascode_current_mirror/untitled-1.sch
**.subckt untitled-1
V1 VDD VSS 6
[expr {fal ? "V2 VIN_N VSS DC 3 AC -0.5
.save i(v2)
.save :(:)
.save "v2vin_nvss("v2vin_nvss)
.save dc(dc)
.save 3(3)
.save ac(ac)
.save -0.5(-0.5)
.save "}]("}])
V3 VIN_P VSS DC 3 AC 0.5
V4 VSS GND 0
I0 Ibias GND 2u
XM1 net1 Ibias VSS VSS nfet_06v0 L=1u W=2.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM2 Ibias Ibias VSS VSS nfet_06v0 L=1u W=5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM3 net2 net2 VDD VDD pfet_06v0 L=1u W=2.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM5 OUT VIN_P net1 VSS nfet_06v0 L=1u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM6 net2 VIN_N net1 VSS nfet_06v0 L=1u W=1u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2)
+ * W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
XM7 OUT net2 VDD VDD pfet_06v0 L=1u W=3.5u nf=1 ad='int((nf+1)/2) * W/nf * 0.18u' as='int((nf+2)/2) *
+ W/nf * 0.18u' pd='2*int((nf+1)/2) * (W/nf + 0.18u)' ps='2*int((nf+2)/2) * (W/nf + 0.18u)' nrd='0.18u
+ / W' nrs='0.18u / W' sa=0 sb=0 sd=0 m=1
**** begin user architecture code


.control
ac dec 100 1 1G
let vdiff = VIN_P - VIN_N
let diff_gain = OUT/vdiff
plot dB(diff_gain)
write test_pfet_03v3.raw
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/smbb000149.ngspice typical

**** end user architecture code
**.ends
.GLOBAL GND
.end
